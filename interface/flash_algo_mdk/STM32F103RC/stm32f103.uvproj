# Keil uVision project stm32f103.uvproj, settings and files
target STM32F103RC (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f103_flash_algo
  c flags: Optim=3
  scatter file: .\Target.lin
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
