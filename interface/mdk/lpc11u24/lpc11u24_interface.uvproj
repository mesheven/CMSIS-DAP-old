# Keil uVision project lpc11u24_interface.uvproj, settings and files
target lpc11u24_lpc1114_if (ARM-ADS)
  device: LPC11U24/401 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: lpc11u24_lpc1114_if_mbed
  AfterMake: fromelf --bin -o @L.bin "#L"
  AfterMake: ..\..\..\tools\fix_checksum.exe @L.bin
  c flags: Optim=4 OneElfS=1
  c define: TARGET_LPC11U35, __RTX, DBG_LPC1114, BOARD_LPC1114
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\target\hal\DBG_NXP\DBG_LPC1114;..\..\interface\hal\TARGET_NXP\TARGET_LPC11U35;..\..\interface\cmsis;..\..\interface\cmsis\TARGET_NXP\TARGET_LPC11UXX;..\..\..\shared\rtos
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: ..\..\..\shared\cmsis\TARGET_NXP\TARGET_LPC11UXX\TOOLCHAIN_ARM_STD\LPC11U35.sct
  group CMSIS
    ../../../shared/cmsis/TARGET_NXP/TARGET_LPC11UXX/: system_LPC11Uxx.c
    ../../../shared/cmsis/TARGET_NXP/TARGET_LPC11UXX/TOOLCHAIN_ARM_STD/: startup_LPC11Uxx.s
  group Common
    ../../Common/src/: DAP.c dap_vendor_command.c main.c RTX_Config.c semihost.c SVC_Table.s SW_DP.c swd_host.c usb_config.c usbd_user_cdc_acm.c usbd_user_hid.c usbd_user_msc.c version.c board.c
    ../../Common/inc/: mbed_htm.h
  group HAL-Interface
    ../../interface/hal/TARGET_NXP/TARGET_LPC11U35/: DAP_config.h gpio.c read_uid.c uart.c usbd_LPC11Uxx.c usb_buf.h
  group HAL-Target
    ../../target/hal/DBG_NXP/DBG_LPC11U24/: target_reset.c
  group USBStack
    ../../../shared/USBStack/SRC/: usbd_cdc_acm.c usbd_core.c usbd_core_cdc.c usbd_core_hid.c usbd_core_msc.c usbd_hid.c usbd_msc.c
  group RTX
    ../../../shared/rtos/: HAL_CM1.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
target lpc11u24_lpc1768_if (ARM-ADS)
  device: LPC11U24/401 NXP (founded by Philips)
  cpu: as above
  output: lpc11u24_lpc1768_if_mbed
  AfterMake: fromelf --bin -o @L.bin "#L"
  AfterMake: ..\..\..\tools\fix_checksum.exe @L.bin
  c flags: Optim=4 OneElfS=1
  c define: TARGET_LPC11U35, __RTX, DBG_LPC1768, BOARD_SEEED_ARCH_PRO
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\target\hal\DBG_NXP\DBG_LPC1768;..\..\interface\hal\TARGET_NXP\TARGET_LPC11U35;..\..\interface\cmsis;..\..\interface\cmsis\TARGET_NXP\TARGET_LPC11UXX;..\..\..\shared\rtos
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: as above
target lpc11u24_ublox_if (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: lpc11u35_lpc1768_if_mbed
  c flags: Optim=1 oTime=1
  c define: TARGET_LPC11U35, __RTX, DBG_LPC1768, BOARD_UBLOX_C027
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: as above
target lpc11u24_lpc11u24_if (ARM-ADS)
  device: LPC11U24/401 NXP (founded by Philips)
  cpu: as above
  output: lpc11u24_lpc11u24_if_mbed
  AfterMake: fromelf --bin -o @L.bin "#L"
  AfterMake: ..\..\..\tools\fix_checksum.exe @L.bin
  c flags: Optim=4 OneElfS=1
  c define: TARGET_LPC11U35, __RTX, DBG_LPC11U24, BOARD_SEEED_ARCH_PRO
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\target\hal\DBG_NXP\DBG_LPC11U24;..\..\interface\hal\TARGET_NXP\TARGET_LPC11U35;..\..\interface\cmsis;..\..\interface\cmsis\TARGET_NXP\TARGET_LPC11UXX;..\..\..\shared\rtos
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: as above
target lpc11u24_lpc812_if (ARM-ADS)
  device: LPC11U24/401 NXP (founded by Philips)
  cpu: as above
  output: lpc11u24_lpc812_if_mbed
  AfterMake: fromelf --bin -o @L.bin "#L"
  AfterMake: ..\..\..\tools\fix_checksum.exe @L.bin
  c flags: Optim=3 oTime=1
  c define: TARGET_LPC11U35, __RTX, DBG_LPC812, BOARD_LPC812_MAX
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\target\hal\DBG_NXP\DBG_LPC812;..\..\interface\hal\TARGET_NXP\TARGET_LPC11U35;..\..\interface\cmsis;..\..\interface\cmsis\TARGET_NXP\TARGET_LPC11UXX;..\..\..\shared\rtos
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: as above
